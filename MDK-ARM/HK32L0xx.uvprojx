# Keil uVision project HK32L0xx.uvprojx, settings and files
target HK32L0xx_L (6130001::V6.13.1::.\ARMCLANG)
  device: HK32L088KBT6 HK_MicroChip
  pack: HKMicroChip.HK32L0xx_DFP.1.0.11
  cpu: IRAM(0x20000000,0x05000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: HK32L0xx_L +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: TARGET_BANK_SLOT_L
  c include: ..\inc;..\..\HK32L08x_SDK_2024-12-02_V1.0.4\Libraries\HK32L0xx_StdPeriphDriver\inc;..\..\HK32L08x_SDK_2024-12-02_V1.0.4\Libraries\CMSIS\CM0\Core;..\..\HK32L08x_SDK_2024-12-02_V1.0.4\Libraries\CMSIS\HK32L0xx\Include;..\..\HK32L08x_SDK_2024-12-02_V1.0.4\Boards\Board_HK32L0xx_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xa000
  memory RVCT9: RAM 0x20000100 size 0x4f00
  link misc: --map --list=build.map
LIBS\lib-otms-l-hk32l08x.lib
  group Start
    ../../HK32L08x_SDK_2024-12-02_V1.0.4/Libraries/CMSIS/HK32L0xx/Source/ARM/: KEIL_Startup_hk32l0xx.s
  group src
    ../../HK32L08x_SDK_2024-12-02_V1.0.4/Libraries/CMSIS/HK32L0xx/Source/: system_hk32l0xx.c
    ../src/: hk32l0xx_it.c main.c
  group HK32L0xx_lib
    ../../HK32L08x_SDK_2024-12-02_V1.0.4/Libraries/HK32L0xx_StdPeriphDriver/src/: hk32l0xx_adc.c hk32l0xx_aes.c hk32l0xx_beep.c hk32l0xx_can.c hk32l0xx_clu.c hk32l0xx_comp.c hk32l0xx_crc.c hk32l0xx_dac.c hk32l0xx_dbgmcu.c hk32l0xx_divsqrt.c hk32l0xx_dma.c hk32l0xx_eeprom.c hk32l0xx_emacc.c hk32l0xx_exti.c hk32l0xx_flash.c hk32l0xx_gpio.c hk32l0xx_i2c.c hk32l0xx_irtim.c hk32l0xx_iwdg.c hk32l0xx_lcd.c hk32l0xx_lpuart.c hk32l0xx_misc.c hk32l0xx_opamp.c hk32l0xx_pwr.c hk32l0xx_rcc.c hk32l0xx_rtc.c hk32l0xx_spi.c hk32l0xx_syscfg.c hk32l0xx_tim.c hk32l0xx_trng.c hk32l0xx_usart.c hk32l0xx_wwdg.c
  group Doc
    ../: Readme.txt
  group OTMS
    ../OTSM/: octopus.c octopus_bsp_hk32l08x.c octopus_gpio_hal.c octopus_key.c octopus_system.c octopus_task_configuration.c octopus_uart_hal.c octopus_vehicle.c
  group INCLUDE
    ../OTSM/: octopus.h octopus_base.h octopus_bsp.h octopus_bsp_hk32l08x.h octopus_bsp_nation.h octopus_cfifo.h octopus_configuration.h octopus_flash.h octopus_flash_hal.h octopus_gpio.h octopus_gpio_hal.h octopus_key.h octopus_log.h octopus_message.h octopus_msgqueue.h octopus_platform.h octopus_system.h octopus_task_manager.h octopus_tickcounter.h octopus_timer_hal.h octopus_uart_hal.h octopus_uart_ptl.h octopus_update_mcu.h octopus_utils.h
